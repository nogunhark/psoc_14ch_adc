# Keil uVision project ADC_4ch_DAC_renew_PSoC3lib.uvproj, settings and files
target Debug (MCS-51)
  device: CY8C3866AXI-040 Cypress
  cpu: "IRAM(0x00-0xFF) IROM(0x0-0xFFFF) CLOCK(67000000) MODDP2"
  output: ADC_4ch_DAC_renew_PSoC3lib (library)
  c flags: Optimize=2
  c define: DEBUG
  c misc: PR(${OutputDir}/${CompileFile}.lst) CD MODDP2
  c include: .;.\Generated_Source\PSoC3
  asm define: DEBUG
  asm misc: NOCO PR(${OutputDir}/${CompileFile}.lst) CASE EP
  asm include: .;.\Generated_Source\PSoC3
  link misc: CODE RU RC(10) IX CL(XDATA(X:0x0000-X:0x1FFF)) CL(CODE(C:0x0000-C:0xFFFF)) CL(CONST(C:0x0000-C:0xFFFF))
  group Source Files
    ./Generated_Source/PSoC3/: cyfitter_cfg.h cyfitter_cfg.c cydevice.h cydevicekeil.inc cydevice_trm.h cydevicekeil_trm.inc cyfitterkeil.inc cyfitter.h cydisabledsheets.h ADC.c ADC.h ADC_PM.c ADC_INT.c ADC_Ext_CP_Clk.c ADC_Ext_CP_Clk.h ADC_IRQ.c ADC_IRQ.h ADC_theACLK.c ADC_theACLK.h CyBootAsmKeil.a51 CyDmac.c CyDmac.h CyFlash.c CyFlash.h CyLib.c CyLib.h cymem.a51 cypins.h cyPm.c cyPm.h CySpc.c CySpc.h cytypes.h cyutils.c PSoC3_8051.h PSoC3_8051.inc project.h UART.c UART.h UART_PM.c UART_INT.c UART_BOOT.c isr_RX.c isr_RX.h UART_IntClock.c UART_IntClock.h Vin_1.c Vin_1.h Vin_1_aliases.h Vin_2.c Vin_2.h Vin_2_aliases.h Vin_3.c Vin_3.h Vin_3_aliases.h Vin_4.c Vin_4.h Vin_4_aliases.h ADC_AMux.c ADC_AMux.h Control.c Control.h Timer.c Timer.h Timer_PM.c isr_1.c isr_1.h Status.c Status.h Vin_5.c Vin_5.h Vin_5_aliases.h Vin_6.c Vin_6.h Vin_6_aliases.h Vin_7.c Vin_7.h Vin_7_aliases.h Vin_8.c Vin_8.h Vin_8_aliases.h Vin_9.c Vin_9.h Vin_9_aliases.h Vin_10.c Vin_10.h Vin_10_aliases.h Vin_11.c Vin_11.h Vin_11_aliases.h Vin_12.c Vin_12.h Vin_12_aliases.h Vin_13.c Vin_13.h Vin_13_aliases.h Vin_14.c Vin_14.h Vin_14_aliases.h
target Release (MCS-51)
  device: CY8C3866AXI-040 Cypress
  cpu: "IRAM(0x00-0xFF) IROM(0x0-0xFFFF) CLOCK(67000000) MODDP2"
  output: ADC_4ch_DAC_renew_PSoC3lib (library)
  c flags: Optimize=8
  c define: NDEBUG
  c misc: PR(${OutputDir}/${CompileFile}.lst) CD MODDP2
  c include: .;.\Generated_Source\PSoC3
  asm define: NDEBUG
  asm misc: NOCO PR(${OutputDir}/${CompileFile}.lst) CASE EP
  asm include: .;.\Generated_Source\PSoC3
  link misc: as above
